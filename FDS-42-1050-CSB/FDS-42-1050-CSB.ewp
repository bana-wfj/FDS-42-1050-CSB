# IAR project FDS-42-1050-CSB.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$; ..\HARDWARE\pingbuffer; ..\HARDWARE\xp2116; ..\HARDWARE\usart
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  AARM.AUserIncludes: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  OBJCOPY.OOCOutputFile: FDS-42-1050-CSB.bin
  ILINK.IlinkOutputFile: FDS-42-1050-CSB.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  ICCARM.CCOptLevel: 3
  group CMSIS-Pack
    RTE/: RTE_Components.h
  group CMSIS-Pack/Device Startup
    RTE/Device/CS32F036F6P7/: startup_cs32f036.S system_cs32f0xx.c
  group CMSIS-Pack/Device.HAL ADC
    ${CMSIS_PACK_PATH_Chipsea#CS32F03x_DFP#2.0.5}$/Device/HAL_Driver/src/: cs32f0xx_adc.c
  group CMSIS-Pack/Device.HAL CRC
    ${CMSIS_PACK_PATH_Chipsea#CS32F03x_DFP#2.0.5}$/Device/HAL_Driver/src/: cs32f0xx_crc.c
  group CMSIS-Pack/Device.HAL DEBUG
    ${CMSIS_PACK_PATH_Chipsea#CS32F03x_DFP#2.0.5}$/Device/HAL_Driver/src/: cs32f0xx_debug.c
  group CMSIS-Pack/Device.HAL DMA
    ${CMSIS_PACK_PATH_Chipsea#CS32F03x_DFP#2.0.5}$/Device/HAL_Driver/src/: cs32f0xx_dma.c
  group CMSIS-Pack/Device.HAL EXTI
    ${CMSIS_PACK_PATH_Chipsea#CS32F03x_DFP#2.0.5}$/Device/HAL_Driver/src/: cs32f0xx_exti.c
  group CMSIS-Pack/Device.HAL Flash
    ${CMSIS_PACK_PATH_Chipsea#CS32F03x_DFP#2.0.5}$/Device/HAL_Driver/src/: cs32f0xx_flash.c
  group CMSIS-Pack/Device.HAL Framework
    RTE/Device/CS32F036F6P7/: cs32f0xx_conf.h
    ${CMSIS_PACK_PATH_Chipsea#CS32F03x_DFP#2.0.5}$/Device/HAL_Driver/src/: cs32f0xx_misc.c
  group CMSIS-Pack/Device.HAL FWDT
    ${CMSIS_PACK_PATH_Chipsea#CS32F03x_DFP#2.0.5}$/Device/HAL_Driver/src/: cs32f0xx_fwdt.c
  group CMSIS-Pack/Device.HAL GPIO
    ${CMSIS_PACK_PATH_Chipsea#CS32F03x_DFP#2.0.5}$/Device/HAL_Driver/src/: cs32f0xx_gpio.c
  group CMSIS-Pack/Device.HAL I2C
    ${CMSIS_PACK_PATH_Chipsea#CS32F03x_DFP#2.0.5}$/Device/HAL_Driver/src/: cs32f0xx_i2c.c
  group CMSIS-Pack/Device.HAL PMU
    ${CMSIS_PACK_PATH_Chipsea#CS32F03x_DFP#2.0.5}$/Device/HAL_Driver/src/: cs32f0xx_pmu.c
  group CMSIS-Pack/Device.HAL RCU
    ${CMSIS_PACK_PATH_Chipsea#CS32F03x_DFP#2.0.5}$/Device/HAL_Driver/src/: cs32f0xx_rcu.c
  group CMSIS-Pack/Device.HAL SPI
    ${CMSIS_PACK_PATH_Chipsea#CS32F03x_DFP#2.0.5}$/Device/HAL_Driver/src/: cs32f0xx_spi.c
  group CMSIS-Pack/Device.HAL SYSCFG
    ${CMSIS_PACK_PATH_Chipsea#CS32F03x_DFP#2.0.5}$/Device/HAL_Driver/src/: cs32f0xx_syscfg.c
  group CMSIS-Pack/Device.HAL TIM
    ${CMSIS_PACK_PATH_Chipsea#CS32F03x_DFP#2.0.5}$/Device/HAL_Driver/src/: cs32f0xx_tim.c
  group CMSIS-Pack/Device.HAL USART
    ${CMSIS_PACK_PATH_Chipsea#CS32F03x_DFP#2.0.5}$/Device/HAL_Driver/src/: cs32f0xx_usart.c
  group CMSIS-Pack/Device.HAL WWDT
    ${CMSIS_PACK_PATH_Chipsea#CS32F03x_DFP#2.0.5}$/Device/HAL_Driver/src/: cs32f0xx_wwdt.c
  group HARDWARE
    ../HARDWARE/pingbuffer/: pingbuffer.c
    ../HARDWARE/usart/: usartx.c
    ../HARDWARE/xp2116/: xp2116.c
  group USER
    ../USER/: main.c
