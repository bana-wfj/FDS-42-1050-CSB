<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\FDS-42-1050-CSB\FDS-42-1050-CSB.ewp</path>
    </project>
    <batchBuild />
</workspace>
